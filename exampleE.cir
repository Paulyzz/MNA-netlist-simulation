V1 2 0 12
R1 3 2 100
E1 1 3 2 3 10
R2 0 3 50
R3 0 1 100
