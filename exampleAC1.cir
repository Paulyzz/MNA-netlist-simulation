V1 1 0 12
R1 1 2 1000
R2 2 0 1000
R3 3 0 1000
L1 1 2 1E-6

.ac 0 1000
