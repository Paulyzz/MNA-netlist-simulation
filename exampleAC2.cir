Vin 1   0   1
R1  1   2   10000
C1  2   0   100E-6

.ac 20  100
