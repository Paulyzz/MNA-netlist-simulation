V1 1 0 12
R1 2 1 100
I1 1 2 5
C1 2 0 0.10
R2 3 2 100
L1 3 0 0.01
R3 3 0 500
